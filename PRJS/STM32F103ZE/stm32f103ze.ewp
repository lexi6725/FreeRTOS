# IAR project stm32f103ze.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\BSP\STM32F103ZE; ..\..\App\STM32F103ZE\include; ..\..\Drivers\STM32F1xx_HAL_Driver\Inc; ..\..\include; ..\..\Kernel\include; ..\..\Kernel\Portable; ..\..\libs\FreeRTOS-Plus-Trace\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: stm32f103ze.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: ..\..\App\STM32F103ZE\stm32f103xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group App
    ../../App/STM32F103ZE/: flash.c hmc5883l.c main.c pwm.c serial.c startup_stm32f103xe.s stm32f1xx_it.c system_stm32f1xx.c
  group BSP
    ../../BSP/STM32F103ZE/: stm3210e_bit3.c
  group Drivers
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Kernel
    ../../Kernel/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Kernel/MemMang
    ../../Kernel/MemMang/: heap_2.c
  group Kernel/Portable
    ../../Kernel/Portable/: port.c portasm.s
  group Libs
    ../../libs/FreeRTOS-Plus-Trace/: trcBase.c trcHardwarePort.c trcKernel.c trcKernelPort.c trcUser.c
