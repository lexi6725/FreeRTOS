<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\stm32f103ze.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\STM32F407VG\stm32f407vg.ewp</path>
  </project>
  <batchBuild/>
</workspace>


