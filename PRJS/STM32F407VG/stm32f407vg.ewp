# IAR project stm32f407vg.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F4xxx ST STM32F4xxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\BSP\STM32F407VG; ..\..\App\STM32F407VG\include; ..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\include; ..\..\Kernel\include; ..\..\Kernel\Portable\ARM_CM4F; ..\..\libs\FreeRTOS-Plus-Trace\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: stm32f407vg.hex
  postbuild: CopyHex_Flash.bat
  ILINK.IlinkOutputFile: stm32f407vg.out
  ILINK.IlinkIcfFile: E:\Documents\STM32\Project\FreeRTOS\App\STM32F407VG\stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: output.hex
  ILINK.IlinkOutputFile: stm32f407vg.hex
  group App
    ../../App/STM32F407VG/: flash.c main.c pwm.c serial.c startup_stm32f407xx.s stm32f4xx_it.c system_stm32f4xx.c
  group BSP
    ../../BSP/STM32F407VG/: stm324xg_eval.c
  group Drivers
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_rcc.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_uart.c
  group Kernel
    ../../Kernel/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Kernel/MenMang
    ../../Kernel/MemMang/: heap_2.c
  group Kernel/Portable
    ../../Kernel/Portable/ARM_CM4F/: port.c portasm.s
